# Keil uVision project My_AT32_Demo.uvprojx, settings and files
target Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32WB415CCU7-7 ArteryTek
  pack: ArteryTek.AT32WB415_DFP.2.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: My_AT32_Demo +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32WB415CCU7_7,USE_STDPERIPH_DRIVER,AT_START_WB415_V1,USE_RTOS
  c include: ..\Bsp;..\Drivers\CMSIS\cm4\device_support;..\Drivers\AT32_Driver\inc;..\User;..\Drivers\CMSIS\cm4\core_support;..\Middlewares\freertos\FreeRTOS\FreeRTOS-Kernel\include;..\Middlewares\freertos\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3;..\Application;..\Middlewares\usb\usb_drivers\inc;..\Middlewares\usb\usbd_class\cdc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ../User/: at32wb415_clock.c at32wb415_int.c main.c at_cmd.c tp_mode.c
  group Bsp
    ../Bsp/: at32wb415_board.c bsp_adc.c bsp_usart.c bsp_pwm.c bsp_wdt.c
  group Application
    ../Application/: start_task.c led_task.c adc_task.c at_task.c usb_task.c
  group Cmsis
    ../Drivers/CMSIS/cm4/device_support/: system_at32wb415.c
    ../Drivers/CMSIS/cm4/device_support/startup/mdk/: startup_at32wb415.s
  group Firmware
    ../Drivers/AT32_Driver/src/: at32wb415_adc.c at32wb415_can.c at32wb415_cmp.c at32wb415_crc.c at32wb415_crm.c at32wb415_debug.c at32wb415_dma.c at32wb415_ertc.c at32wb415_exint.c at32wb415_flash.c at32wb415_gpio.c at32wb415_i2c.c at32wb415_misc.c at32wb415_pwc.c at32wb415_spi.c at32wb415_tmr.c at32wb415_usart.c at32wb415_usb.c at32wb415_wdt.c at32wb415_wwdt.c
  group Middlewares/FreeRTOS
    ../Middlewares/freertos/FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/freertos/FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../Middlewares/freertos/FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/USB_Driver
    ../Middlewares/usb/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
    ../Middlewares/usb/usbd_class/cdc/: cdc_class.c cdc_desc.c
